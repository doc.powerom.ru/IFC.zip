Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-26T23:51:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 26 23:51:39 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{3CC3634A-A711-4275-9B36-A929C7F9E3FE}\ifc * Database version: 5507 * Database creation date: Wed Feb 26 23:51:37 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 26 23:51:37 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 26 23:51:37 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 200х300х400 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х300х400 мм (ГхШхВ):1805183
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х300х400 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0432; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х300х400 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; Имя типа: 200х300х400 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 6.8; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Смещение от уровня: 1000 mm; DKC_Тип крепления: Нет; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 360
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х400 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х400 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х400 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х400 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.024 m3; Площадь: 0.59 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х300х500 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х300х500 мм (ГхШхВ):2010977
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х300х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0532; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х300х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х300х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 8.3; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1712
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х300х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.03 m3; Площадь: 0.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х400 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х400х400 мм (ГхШхВ):2011052
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х400х400 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0442; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х400х400 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х400 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 8.6; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1715
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х400 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х400 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х400 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х400 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.032 m3; Площадь: 0.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х500 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х400х500 мм (ГхШхВ):2011124
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х400х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0542; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х400х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 10.4; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1718
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.04 m3; Площадь: 0.94 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х600 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х400х600 мм (ГхШхВ):2011194
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х400х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0642; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х400х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 12.4; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1721
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х400х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.048 m3; Площадь: 1.08 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х500х500 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х500х500 мм (ГхШхВ):2011273
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х500х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0552; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х500х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х500х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 12.4; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1724
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.05 m3; Площадь: 1.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х500х700 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х500х700 мм (ГхШхВ):2011344
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х500х700 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0752; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х500х700 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х500х700 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 700 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 17; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1727
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х700 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х700 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х700 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х500х700 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.07 m3; Площадь: 1.54 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х600х400 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:200х600х400 мм (ГхШхВ):2011425
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 200х600х400 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0462; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 200х600х400 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х600х400 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 12.6; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1730
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х600х400 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х600х400 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х600х400 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 200х600х400 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.048 m3; Площадь: 1.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х400х500 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х400х500 мм (ГхШхВ):2011517
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х400х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0549; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х400х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х400х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 11.1; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1736
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.05 m3; Площадь: 0.985 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х400х600 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х400х600 мм (ГхШхВ):2011588
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х400х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0649; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х400х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х400х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 13.3; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1739
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х400х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.06 m3; Площадь: 1.13 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х500х700 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х500х700 мм (ГхШхВ):2011670
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х500х700 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0759; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х500х700 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х500х700 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 700 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 18.1; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1742
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х500х700 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х500х700 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х500х700 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х500х700 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.0875 m3; Площадь: 1.6 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х600х1000 мм (ГхШхВ):2011906
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1069; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 28.6; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1751
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.15 m3; Площадь: 2.56 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х600 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х600х600 мм (ГхШхВ):2011748
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0669; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 18.5; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1745
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.09 m3; Площадь: 1.74 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х800 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:250х600х800 мм (ГхШхВ):2011827
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 250х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0869; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 250х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 23.5; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1748
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 250х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.12 m3; Площадь: 2.15 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х600х1000 мм (ГхШхВ):2012087
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 300х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1063; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 300х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 32; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1760
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.18 m3; Площадь: 2.64 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х1200 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х600х1200 мм (ГхШхВ):2012175
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 300х600х1200 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1263; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 300х600х1200 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х1200 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
