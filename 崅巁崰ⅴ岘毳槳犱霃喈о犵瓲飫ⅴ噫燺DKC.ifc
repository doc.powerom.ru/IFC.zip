Properties of the parts of a building model (IFC4), part 2 of 2

# IfcElectricDistributionBoard: 300х600х1200 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х600х1200 мм (ГхШхВ):2012175
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 35.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1763
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1200 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1200 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1200 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х1200 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.216 m3; Площадь: 3.06 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х800 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х600х800 мм (ГхШхВ):2012008
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 300х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0863; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 300х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 26.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1757
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.144 m3; Площадь: 2.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х800х1000 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х800х1000 мм (ГхШхВ):2012273
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 300х800х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1083; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 300х800х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х800х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 38.1; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1766
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.24 m3; Площадь: 3.58 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х800х1200 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:300х800х1200 мм (ГхШхВ):2012357
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 300х800х1200 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1283; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 300х800х1200 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х800х1200 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 44.7; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1769
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1200 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1200 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1200 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 300х800х1200 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.288 m3; Площадь: 4.12 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х400х600 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х400х600 мм (ГхШхВ):2012448
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х400х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0644; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х400х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х400х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 18.22; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1772
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х400х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х400х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х400х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х400х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.096 m3; Площадь: 1.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х600х1000 мм (ГхШхВ):2012625
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1064; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 33.7; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1781
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.24 m3; Площадь: 2.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х1200 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х600х1200 мм (ГхШхВ):2012781
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х600х1200 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1264; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х600х1200 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х1200 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 39.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1784
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1200 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1200 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1200 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х1200 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.288 m3; Площадь: 3.24 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х600 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х600х600 мм (ГхШхВ):2012529
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0664; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 21.8; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1775
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.144 m3; Площадь: 1.92 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х800 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х600х800 мм (ГхШхВ):2012613
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX0864; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 28; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1778
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.192 m3; Площадь: 2.36 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х1000 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х800х1000 мм (ГхШхВ):2012883
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х800х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1084; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х800х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 42.3; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1787
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.32 m3; Площадь: 3.76 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х1200 мм (ГхШхВ), НВО_НавесныеШкафыПрозрачнаяДверца_DKC:400х800х1200 мм (ГхШхВ):2012967
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф STX с прозрачной дверцей 400х800х1200 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STX1284; ADSK_Наименование: Сборный шкаф STX с прозрачной дверцей 400х800х1200 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыПрозрачнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/864/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х1200 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф STX с прозрачной дверцей
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Напольное: Напольное крепление; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыПрозрачнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 49.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1790
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1200 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1200 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1200 мм (ГхШхВ); Тип: НВО_НавесныеШкафыПрозрачнаяДверца_DKC: 400х800х1200 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.384 m3; Площадь: 4.32 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
