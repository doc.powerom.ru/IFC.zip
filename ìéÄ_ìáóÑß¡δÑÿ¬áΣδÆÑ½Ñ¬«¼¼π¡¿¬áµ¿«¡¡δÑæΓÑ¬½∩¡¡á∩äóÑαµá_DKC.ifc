Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-27T00:17:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 27 00:17:06 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{1303FF93-6CE9-44ED-B84D-2B9AEC8A21A8}\ifc * Database version: 5507 * Database creation date: Thu Feb 27 00:17:03 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Feb 27 00:17:04 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 27 00:17:04 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: IP31 RAL7035 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 400х600х1000 мм (ГхШхВ):2035454
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI2040GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 400х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 33; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1894
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.24 m3; Площадь: 2.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 400х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 400х600х500 мм (ГхШхВ):1842353
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI0940GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; DKC_Перфорация: yes; ETIM Article Class: EC002500
Type - Идентификация - ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; Имя типа: IP31 RAL7035 400х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 21.28; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 383
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.12 m3; Площадь: 1.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 400х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 400х600х600 мм (ГхШхВ):2035386
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1240GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 400х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 23.04; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1890
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.144 m3; Площадь: 1.92 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 400х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 400х600х800 мм (ГхШхВ):2035416
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1640GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 400х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 400х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 28.02; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1892
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 400х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.192 m3; Площадь: 2.36 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 650х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 650х600х1000 мм (ГхШхВ):2035470
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI2065GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 650х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 55.5; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1902
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.39 m3; Площадь: 3.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 650х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 650х600х500 мм (ГхШхВ):2035464
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI0965GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 650х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 38.6; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1896
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.195 m3; Площадь: 1.975 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 650х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 650х600х600 мм (ГхШхВ):2035466
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1265GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 650х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 43.5; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1898
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.234 m3; Площадь: 2.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL7035 650х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL7035 650х600х800 мм (ГхШхВ):2035468
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1665GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL7035 650х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL7035 650х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 37.1; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1900
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL7035 650х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.312 m3; Площадь: 2.71 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 400х600х1000 мм (ГхШхВ):2035590
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI2040GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 400х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 32.88; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1910
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.24 m3; Площадь: 2.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 400х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 400х600х500 мм (ГхШхВ):2035584
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI0940GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 400х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 21.21; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1904
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.12 m3; Площадь: 1.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 400х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 400х600х600 мм (ГхШхВ):2035586
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1240GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 400х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 23.05; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1906
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.144 m3; Площадь: 1.92 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 400х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 400х600х800 мм (ГхШхВ):2035588
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1640GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 400х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 400х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 27.92; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1908
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 400х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.192 m3; Площадь: 2.36 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 650х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 650х600х1000 мм (ГхШхВ):2035598
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI2065GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 650х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 55.5; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1918
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.39 m3; Площадь: 3.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 650х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 650х600х500 мм (ГхШхВ):2035592
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI0965GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 650х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 38.7; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1912
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.195 m3; Площадь: 1.975 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 650х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 650х600х600 мм (ГхШхВ):2035594
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1265GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 650х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 32.24; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1914
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.234 m3; Площадь: 2.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP31 RAL9005 650х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP31 RAL9005 650х600х800 мм (ГхШхВ):2035596
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: yes; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STI1665GSB; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP31 RAL9005 650х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP31 RAL9005 650х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 39; DKC_IK: 10; DKC_IP: IP31; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1916
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP31 RAL9005 650х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.312 m3; Площадь: 2.71 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC:IP54 RAL7035 400х600х1000 мм (ГхШхВ):2035818
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC, BIMLIB_Стекло_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP54 RAL7035 400х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP2040GS; ADSK_Наименование: Навесной телекоммуникационный шкаф со стеклянной дверцей IP54 RAL7035 400х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 400х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 33; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1926
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP54 RAL7035 400х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP54 RAL7035 400х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP54 RAL7035 400х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеСтекляннаяДверца_DKC: IP54 RAL7035 400х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.24 m3; Площадь: 2.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
