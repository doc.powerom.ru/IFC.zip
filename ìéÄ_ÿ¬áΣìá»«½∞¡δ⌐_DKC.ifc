Properties of the parts of a building model (IFC4), part 3 of 4

# IfcElectricDistributionBoard: 400х600х1400 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х600х1400 (ГхШхВ) мм:1747545
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; Имя типа: 400х600х1400 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1400 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 43.765; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 330
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х600х1400 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х600х1400 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х600х1400 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х600х1400 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.36 m3; Площадь: 3.9 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х1600 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х600х1600 (ГхШхВ) мм:1870530
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х600х1600мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1664; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х600х1600мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х1600 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 54.66; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 395
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х600х1600 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х600х1600 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х600х1600 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х600х1600 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.408 m3; Площадь: 4.34 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х600х1800 (ГхШхВ) мм:1870572
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х600х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1864; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х600х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 55.4; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 408
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х600х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х600х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х600х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х600х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.456 m3; Площадь: 4.78 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х600х2000 (ГхШхВ) мм:1870616
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2064; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 64.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 421
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.504 m3; Площадь: 5.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х1400 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х800х1400 (ГхШхВ) мм:1870661
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х800х1400мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1484; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х800х1400мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х1400 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1400 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 51.426; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 434
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х800х1400 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х800х1400 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х800х1400 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х800х1400 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.48 m3; Площадь: 5.16 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х1600 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х800х1600 (ГхШхВ) мм:1870710
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х800х1600мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1684; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х800х1600мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х1600 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 68.46; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 447
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х800х1600 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х800х1600 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х800х1600 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х800х1600 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.544 m3; Площадь: 5.72 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х800х1800 (ГхШхВ) мм:1870763
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х800х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1884; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х800х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 73.1; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 460
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х800х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х800х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х800х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х800х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.608 m3; Площадь: 6.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х800х2000 (ГхШхВ) мм:1870808
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2084; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 79.38; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 473
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.672 m3; Площадь: 6.84 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 500х600х1600 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:500х600х1600 (ГхШхВ) мм:1870903
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 500х600х1600мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1665; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 500х600х1600мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 500х600х1600 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1600 mm; ADSK_Размер_Глубина: 500 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 58.66; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 499
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 500х600х1600 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 500х600х1600 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 500х600х1600 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 500х600х1600 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.51 m3; Площадь: 4.57 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 500х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:500х600х2000 (ГхШхВ) мм:1870959
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 500х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2065; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 500х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 500х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 500 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 68.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 512
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 500х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 500х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 500х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 500х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.63 m3; Площадь: 5.49 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 500х800х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:500х800х1800 (ГхШхВ) мм:1871017
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 500х800х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1885; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 500х800х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 500х800х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 500 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 76.6; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 525
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 500х800х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 500х800х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 500х800х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 500х800х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.76 m3; Площадь: 6.55 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 500х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:500х800х2000 (ГхШхВ) мм:1871065
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 500х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2085; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 500х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 500х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 500 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 82.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 538
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 500х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 500х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 500х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 500х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.84 m3; Площадь: 7.13 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х1000х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х1000х1800 (ГхШхВ) мм:1871337
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х1000х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18106; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х1000х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х1000х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 108.6; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 642
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х1000х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х1000х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х1000х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х1000х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.14 m3; Площадь: 8.44 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х1000х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х1000х2000 (ГхШхВ) мм:1871387
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х1000х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20106; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х1000х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х1000х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 103.38; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 655
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х1000х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х1000х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х1000х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х1000х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.26 m3; Площадь: 9.16 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х1200х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х1200х2000 (ГхШхВ) мм:1871433
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х1200х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20126; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х1200х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х1200х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 122.58; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 668
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х1200х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х1200х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х1200х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х1200х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.512 m3; Площадь: 10.98 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х600х1600 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х600х1600 (ГхШхВ) мм:1871110
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х600х1600мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1666; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х600х1600мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х600х1600 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1600 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 59.861; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 551
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х600х1600 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х600х1600 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х600х1600 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х600х1600 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.612 m3; Площадь: 4.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х600х2000 (ГхШхВ) мм:1871195
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2066; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
