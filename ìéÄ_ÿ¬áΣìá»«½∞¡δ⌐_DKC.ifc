Properties of the parts of a building model (IFC4), part 4 of 4

# IfcElectricDistributionBoard: 600х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х600х2000 (ГхШхВ) мм:1871195
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 70.081; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 603
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.756 m3; Площадь: 5.76 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х800х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х800х1800 (ГхШхВ) мм:1871240
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х800х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1886; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х800х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х800х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 78.6; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 616
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х800х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х800х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х800х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х800х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.912 m3; Площадь: 6.82 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 600х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:600х800х2000 (ГхШхВ) мм:1871288
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 600х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2086; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 600х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 600х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 600 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 84.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 629
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 600х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 600х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 600х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 600х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.008 m3; Площадь: 7.42 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 800х400х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:800х400х1800 (ГхШхВ) мм:1871481
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 800х400х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1848; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 800х400х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 800х400х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 57.001; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 681
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 800х400х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 800х400х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 800х400х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 800х400х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.608 m3; Площадь: 4.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 800х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:800х600х2000 (ГхШхВ) мм:1871606
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 800х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2068; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 800х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 800х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 74.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 772
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 800х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 800х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 800х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 800х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.008 m3; Площадь: 6.3 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 800х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:800х800х2000 (ГхШхВ) мм:1871640
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 800х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE2088; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 800х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 800х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 97.14; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 785
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 800х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 800х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 800х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 800х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.344 m3; Площадь: 8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: DKC_Боковые панели (53)
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Material: BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Обозначение: ГОСТ Р 32127
Type - Идентификация - ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; ДКС_Таблица артикулы: ДКС_боковые панели; Изготовитель: DKC; Имя типа: DKC_Боковые панели; Комментарии к типоразмеру: 2. Комплектующие; Описание: Боковые панели
Type - Прочее - Категория: Электрооборудование; Имя семейства: DKC_Боковые панели
Type - Электросети - Нагрузки - ADSK_Напряжение: 0 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Данные - DKC_Код комплектации: 100111111111
Зависимости - Перемещать с соседними элементами: no; Основа: Уровень : Этаж 01; Смещение: 200 mm; Уровень: Уровень: Этаж 01
Материалы и отделка - Материал: BIMLIB_СерыйRAL7035_DKC
Прочее - Код типа: DKC_Боковые панели: DKC_Боковые панели; Семейство: DKC_Боковые панели: DKC_Боковые панели; Семейство и типоразмер: DKC_Боковые панели: DKC_Боковые панели; Тип: DKC_Боковые панели: DKC_Боковые панели
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
Name (DKC_Боковые панели:DKC_Боковые панели:...) | ADSK_Группирование | ADSK_Код изделия | ADSK_Наименование | Марка | ADSK_Размер_Высота (mm) | ADSK_Размер_Глубина (mm) | ADSK_Размер_Ширина (mm) | Объем (m3) | Площадь (m2) | ADSK_Масса
1747555 | Сборный шкаф CQE с дверью и задней панелью 400х600х1400мм (ГхШхВ) | R5LE1442 | Боковые панели 400х1400мм (ГхВ) | 340 | 1400 | 400 | 600 | 0.002176 | 1.09504 | 12.3 | Идентификация - Вариант конструкции: Главная модель
1870539 | Сборный шкаф CQE с дверью и задней панелью 400х600х1600мм (ГхШхВ) | R5LE1642 | Боковые панели 400х1600мм (ГхВ) | 404 | 1600 | 400 | 600 | 0.002496 | 1.25584 | 15 | Идентификация - Вариант конструкции: Главная модель
1870581 | Сборный шкаф CQE с дверью и задней панелью 400х600х1800мм (ГхШхВ) | R5LE1842 | Боковые панели 400х1800мм (ГхВ) | 417 | 1800 | 400 | 600 | 0.002816 | 1.41664 | 15.8
1870625 | Сборный шкаф CQE с дверью и задней панелью 400х600х2000мм (ГхШхВ) | R5LE2042 | Боковые панели 400х2000мм (ГхВ) | 430 | 2000 | 400 | 600 | 0.003136 | 1.57744 | 18
1870670 | Сборный шкаф CQE с дверью и задней панелью 400х800х1400мм (ГхШхВ) | R5LE1442 | Боковые панели 400х1400мм (ГхВ) | 443 | 1400 | 400 | 800 | 0.002176 | 1.09504 | 12.3 | Идентификация - Вариант конструкции: Главная модель
1870719 | Сборный шкаф CQE с дверью и задней панелью 400х800х1600мм (ГхШхВ) | R5LE1642 | Боковые панели 400х1600мм (ГхВ) | 456 | 1600 | 400 | 800 | 0.002496 | 1.25584 | 15 | Идентификация - Вариант конструкции: Главная модель
1870772 | Сборный шкаф CQE с дверью и задней панелью 400х800х1800мм (ГхШхВ) | R5LE1842 | Боковые панели 400х1800мм (ГхВ) | 469 | 1800 | 400 | 800 | 0.002816 | 1.41664 | 15.8 | Идентификация - Вариант конструкции: Главная модель
1870817 | Сборный шкаф CQE с дверью и задней панелью 400х800х2000мм (ГхШхВ) | R5LE2042 | Боковые панели 400х2000мм (ГхВ) | 482 | 2000 | 400 | 800 | 0.003136 | 1.57744 | 18 | Идентификация - Вариант конструкции: Главная модель
1870862 | Сборный шкаф CQE с дверью и задней панелью 400х1000х1800мм (ГхШхВ) | R5LE1842 | Боковые панели 400х1800мм (ГхВ) | 495 | 1800 | 400 | 1000 | 0.002816 | 1.41664 | 15.8
1870912 | Сборный шкаф CQE с дверью и задней панелью 500х600х1600мм (ГхШхВ) | R5LE1652 | Боковые панели 500х1600мм (ГхВ) | 508 | 1600 | 500 | 600 | 0.00312 | 1.56824 | 17.5 | Идентификация - Вариант конструкции: Главная модель
1870968 | Сборный шкаф CQE с дверью и задней панелью 500х600х2000мм (ГхШхВ) | R5LE2052 | Боковые панели 500х2000мм (ГхВ) | 521 | 2000 | 500 | 600 | 0.00392 | 1.96984 | 24.001
1871026 | Сборный шкаф CQE с дверью и задней панелью 500х800х1800мм (ГхШхВ) | R5LE1852 | Боковые панели 500х1800мм (ГхВ) | 534 | 1800 | 500 | 800 | 0.00352 | 1.76904 | 22.501
1871074 | Сборный шкаф CQE с дверью и задней панелью 500х800х2000мм (ГхШхВ) | R5LE2052 | Боковые панели 500х2000мм (ГхВ) | 547 | 2000 | 500 | 800 | 0.00392 | 1.96984 | 24.001
1871119 | Сборный шкаф CQE с дверью и задней панелью 600х600х1600мм (ГхШхВ) | R5LE1662 | Боковые панели 600х1600мм (ГхВ) | 560 | 1600 | 600 | 600 | 0.003744 | 1.88064 | 18
1871204 | Сборный шкаф CQE с дверью и задней панелью 600х600х2000мм (ГхШхВ) | R5LE2062 | Боковые панели 600х2000мм (ГхВ) | 612 | 2000 | 600 | 600 | 0.004704 | 2.36224 | 26.5 | Идентификация - Вариант конструкции: Главная модель
1871249 | Сборный шкаф CQE с дверью и задней панелью 600х800х1800мм (ГхШхВ) | R5LE1862 | Боковые панели 600х1800мм (ГхВ) | 625 | 1800 | 600 | 800 | 0.004224 | 2.12144 | 25
1871297 | Сборный шкаф CQE с дверью и задней панелью 600х800х2000мм (ГхШхВ) | R5LE2062 | Боковые панели 600х2000мм (ГхВ) | 638 | 2000 | 600 | 800 | 0.004704 | 2.36224 | 26.5 | Идентификация - Вариант конструкции: Главная модель
1871346 | Сборный шкаф CQE с дверью и задней панелью 600х1000х1800мм (ГхШхВ) | R5LE1862 | Боковые панели 600х1800мм (ГхВ) | 651 | 1800 | 600 | 1000 | 0.004224 | 2.12144 | 25
1871396 | Сборный шкаф CQE с дверью и задней панелью 600х1000х2000мм (ГхШхВ) | R5LE2062 | Боковые панели 600х2000мм (ГхВ) | 664 | 2000 | 600 | 1000 | 0.004704 | 2.36224 | 26.5
1871442 | Сборный шкаф CQE с дверью и задней панелью 600х1200х2000мм (ГхШхВ) | R5LE2062 | Боковые панели 600х2000мм (ГхВ) | 677 | 2000 | 600 | 1200 | 0.004704 | 2.36224 | 26.5
1871490 | Сборный шкаф CQE с дверью и задней панелью 800х400х1800мм (ГхШхВ) | R5LE1882 | Боковые панели 800х1800мм (ГхВ) | 690 | 1800 | 800 | 400 | 0.005632 | 2.82624 | 35.5 | Идентификация - Вариант конструкции: Главная модель
1871615 | Сборный шкаф CQE с дверью и задней панелью 800х600х2000мм (ГхШхВ) | R5LE2082 | Боковые панели 800х2000мм (ГхВ) | 781 | 2000 | 800 | 600 | 0.006272 | 3.14704 | 38.5
1871649 | Сборный шкаф CQE с дверью и задней панелью 800х800х2000мм (ГхШхВ) | R5LE2082 | Боковые панели 800х2000мм (ГхВ) | 794 | 2000 | 800 | 800 | 0.006272 | 3.14704 | 38.5 | Идентификация - Вариант конструкции: Главная модель
1872161 | Сборный шкаф CQE с дверью и задней панелью 1000х400х1800мм (ГхШхВ) | R5LE18102 | Боковые панели 1000х1800мм (ГхВ) | 876 | 1800 | 1000 | 400 | 0.00704 | 3.53104 | 34
1872237 | Сборный шкаф CQE с дверью и задней панелью 1000х400х2000мм (ГхШхВ) | R5LE20102 | Боковые панели 1000х2000мм (ГхВ) | 915 | 2000 | 1000 | 400 | 0.00784 | 3.93184 | 38
1872282 | Сборный шкаф CQE с дверью и задней панелью 1000х400х2200мм (ГхШхВ) | R5LE22102 | Боковые панели 1000х2200мм (ГхВ) | 928 | 2200 | 1000 | 400 | 0.00864 | 4.33264 | 42 | Идентификация - Вариант конструкции: Главная модель
1873609 | Сборный шкаф CQE с дверью и задней панелью 1200х1200х2200мм (ГхШхВ) | R5LE22122 | Боковые панели 1200х2200мм (ГхВ) | 1292 | 2200 | 1200 | 1200 | 0.010368 | 5.19744 | 27.5 | Идентификация - Вариант конструкции: Главная модель
1872329 | Сборный шкаф CQE с дверью и задней панелью 1000х600х1800мм (ГхШхВ) | R5LE18102 | Боковые панели 1000х1800мм (ГхВ) | 941 | 1800 | 1000 | 600 | 0.00704 | 3.53104 | 34
1872383 | Сборный шкаф CQE с дверью и задней панелью 1000х600х2000мм (ГхШхВ) | R5LE20102 | Боковые панели 1000х2000мм (ГхВ) | 954 | 2000 | 1000 | 600 | 0.00784 | 3.93184 | 38
1872429 | Сборный шкаф CQE с дверью и задней панелью 1000х600х2200мм (ГхШхВ) | R5LE22102 | Боковые панели 1000х2200мм (ГхВ) | 967 | 2200 | 1000 | 600 | 0.00864 | 4.33264 | 42
1872476 | Сборный шкаф CQE с дверью и задней панелью 1000х800х1800мм (ГхШхВ) | R5LE18102 | Боковые панели 1000х1800мм (ГхВ) | 980 | 1800 | 1000 | 800 | 0.00704 | 3.53104 | 34
1872526 | Сборный шкаф CQE с дверью и задней панелью 1000х800х2000мм (ГхШхВ) | R5LE20102 | Боковые панели 1000х2000мм (ГхВ) | 993 | 2000 | 1000 | 800 | 0.00784 | 3.93184 | 38 | Идентификация - Вариант конструкции: Главная модель
1872573 | Сборный шкаф CQE с дверью и задней панелью 1000х800х2200мм (ГхШхВ) | R5LE22102 | Боковые панели 1000х2200мм (ГхВ) | 1006 | 2200 | 1000 | 800 | 0.00864 | 4.33264 | 42 | Идентификация - Вариант конструкции: Главная модель
1872620 | Сборный шкаф CQE с дверью и задней панелью 1000х1000х1800мм (ГхШхВ) | R5LE18102 | Боковые панели 1000х1800мм (ГхВ) | 1019 | 1800 | 1000 | 1000 | 0.00704 | 3.53104 | 34 | Идентификация - Вариант конструкции: Главная модель
1872669 | Сборный шкаф CQE с дверью и задней панелью 1000х1000х2000мм (ГхШхВ) | R5LE20102 | Боковые панели 1000х2000мм (ГхВ) | 1032 | 2000 | 1000 | 1000 | 0.00784 | 3.93184 | 38 | Идентификация - Вариант конструкции: Главная модель
1872712 | Сборный шкаф CQE с дверью и задней панелью 1000х1000х2200мм (ГхШхВ) | R5LE22102 | Боковые панели 1000х2200мм (ГхВ) | 1045 | 2200 | 1000 | 1000 | 0.00864 | 4.33264 | 42
1872755 | Сборный шкаф CQE с дверью и задней панелью 1000х1200х1800мм (ГхШхВ) | R5LE18102 | Боковые панели 1000х1800мм (ГхВ) | 1058 | 1800 | 1000 | 1200 | 0.00704 | 3.53104 | 34
1872822 | Сборный шкаф CQE с дверью и задней панелью 1000х1200х2000мм (ГхШхВ) | R5LE20102 | Боковые панели 1000х2000мм (ГхВ) | 1071 | 2000 | 1000 | 1200 | 0.00784 | 3.93184 | 38
1872870 | Сборный шкаф CQE с дверью и задней панелью 1000х1200х2200мм (ГхШхВ) | R5LE22102 | Боковые панели 1000х2200мм (ГхВ) | 1084 | 2200 | 1000 | 1200 | 0.00864 | 4.33264 | 42 | Идентификация - Вариант конструкции: Главная модель
1872939 | Сборный шкаф CQE с дверью и задней панелью 1200х400х1800мм (ГхШхВ) | R5LE18122 | Боковые панели 1200х1800мм (ГхВ) | 1110 | 1800 | 1200 | 400 | 0.008448 | 4.23584 | 49 | Идентификация - Вариант конструкции: Главная модель
1872989 | Сборный шкаф CQE с дверью и задней панелью 1200х400х2000мм (ГхШхВ) | R5LE20122 | Боковые панели 1200х2000мм (ГхВ) | 1123 | 2000 | 1200 | 400 | 0.009408 | 4.71664 | 52.001 | Идентификация - Вариант конструкции: Главная модель
1873038 | Сборный шкаф CQE с дверью и задней панелью 1200х400х2200мм (ГхШхВ) | R5LE22122 | Боковые панели 1200х2200мм (ГхВ) | 1136 | 2200 | 1200 | 400 | 0.010368 | 5.19744 | 27.5
1873088 | Сборный шкаф CQE с дверью и задней панелью 1200х600х1800мм (ГхШхВ) | R5LE18122 | Боковые панели 1200х1800мм (ГхВ) | 1149 | 1800 | 1200 | 600 | 0.008448 | 4.23584 | 49
1873123 | Сборный шкаф CQE с дверью и задней панелью 1200х600х2000мм (ГхШхВ) | R5LE20122 | Боковые панели 1200х2000мм (ГхВ) | 1162 | 2000 | 1200 | 600 | 0.009408 | 4.71664 | 52.001 | Идентификация - Вариант конструкции: Главная модель
1873169 | Сборный шкаф CQE с дверью и задней панелью 1200х600х2200мм (ГхШхВ) | R5LE22122 | Боковые панели 1200х2200мм (ГхВ) | 1175 | 2200 | 1200 | 600 | 0.010368 | 5.19744 | 27.5 | Идентификация - Вариант конструкции: Главная модель
1873562 | Сборный шкаф CQE с дверью и задней панелью 1200х1200х2000мм (ГхШхВ) | R5LE20122 | Боковые панели 1200х2000мм (ГхВ) | 1279 | 2000 | 1200 | 1200 | 0.009408 | 4.71664 | 52.001
1873215 | Сборный шкаф CQE с дверью и задней панелью 1200х800х1800мм (ГхШхВ) | R5LE18122 | Боковые панели 1200х1800мм (ГхВ) | 1188 | 1800 | 1200 | 800 | 0.008448 | 4.23584 | 49 | Идентификация - Вариант конструкции: Главная модель
1873266 | Сборный шкаф CQE с дверью и задней панелью 1200х800х2000мм (ГхШхВ) | R5LE20122 | Боковые панели 1200х2000мм (ГхВ) | 1201 | 2000 | 1200 | 800 | 0.009408 | 4.71664 | 52.001 | Идентификация - Вариант конструкции: Главная модель
1873315 | Сборный шкаф CQE с дверью и задней панелью 1200х800х2200мм (ГхШхВ) | R5LE22122 | Боковые панели 1200х2200мм (ГхВ) | 1214 | 2200 | 1200 | 800 | 0.010368 | 5.19744 | 27.5 | Идентификация - Вариант конструкции: Главная модель
1873362 | Сборный шкаф CQE с дверью и задней панелью 1200х1000х1800мм (ГхШхВ) | R5LE18122 | Боковые панели 1200х1800мм (ГхВ) | 1227 | 1800 | 1200 | 1000 | 0.008448 | 4.23584 | 49
1873412 | Сборный шкаф CQE с дверью и задней панелью 1200х1000х2000мм (ГхШхВ) | R5LE20122 | Боковые панели 1200х2000мм (ГхВ) | 1240 | 2000 | 1200 | 1000 | 0.009408 | 4.71664 | 52.001
1873462 | Сборный шкаф CQE с дверью и задней панелью 1200х1000х2200мм (ГхШхВ) | R5LE22122 | Боковые панели 1200х2200мм (ГхВ) | 1253 | 2200 | 1200 | 1000 | 0.010368 | 5.19744 | 27.5
1873513 | Сборный шкаф CQE с дверью и задней панелью 1200х1200х1800мм (ГхШхВ) | R5LE18122 | Боковые панели 1200х1800мм (ГхВ) | 1266 | 1800 | 1200 | 1200 | 0.008448 | 4.23584 | 49
