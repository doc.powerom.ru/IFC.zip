Properties of the parts of a building model (IFC4), part 1 of 4

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-26T22:48:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 26 22:48:49 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{B31B7B5B-4A13-466B-AF99-D7D9F6DCF85E}\ifc * Database version: 5507 * Database creation date: Wed Feb 26 22:48:42 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 26 22:48:43 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 26 22:48:43 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Прочее - Категория: Сведения о проекте
Идентификация - Вариант конструкции: Главная модель
Данные - ADSK_Титул Год выпуска: 2019

# IfcBuilding
Прочее - Категория: Сведения о проекте
Идентификация - Вариант конструкции: Главная модель
Данные - ADSK_Титул Год выпуска: 2019
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 1000х1000х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1000х1800 (ГхШхВ) мм:1872611
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE181010; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1000х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 118.1; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1010
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1000х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1000х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1000х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1000х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.9 m3; Площадь: 9.6 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х1000х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1000х2000 (ГхШхВ) мм:1872660
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE201010; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1000х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 112.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1023
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1000х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1000х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1000х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1000х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.1 m3; Площадь: 10.4 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х1000х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1000х2200 (ГхШхВ) мм:1872703
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE221010; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1000х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1000х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 116.07; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1036
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1000х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1000х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1000х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1000х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.3 m3; Площадь: 11.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х1200х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1200х1800 (ГхШхВ) мм:1872746
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE181210; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1200х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 130.1; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1049
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1200х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1200х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1200х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1200х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.28 m3; Площадь: 11.38 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х1200х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1200х2000 (ГхШхВ) мм:1872813
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE201210; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1200х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 135.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1062
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1200х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1200х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1200х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1200х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.52 m3; Площадь: 12.3 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х1200х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х1200х2200 (ГхШхВ) мм:1872861
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE221210; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х1200х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х1200х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 151.07; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1075
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х1200х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х1200х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х1200х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х1200х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.76 m3; Площадь: 13.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х400х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х400х1800 (ГхШхВ) мм:1872152
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х400х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18410; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х400х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х400х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 60.3; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 867
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х400х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х400х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х400х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х400х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.76 m3; Площадь: 4.74 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х400х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х400х2000 (ГхШхВ) мм:1872228
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х400х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20410; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х400х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х400х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 65.08; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 906
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х400х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х400х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х400х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х400х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.84 m3; Площадь: 5.18 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х400х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х400х2200 (ГхШхВ) мм:1872273
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х400х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22410; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х400х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х400х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 69.27; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 919
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х400х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х400х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х400х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х400х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.92 m3; Площадь: 5.62 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х600х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х600х1800 (ГхШхВ) мм:1872320
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х600х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18610; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х600х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х600х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 71.7; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 932
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х600х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х600х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х600х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х600х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.14 m3; Площадь: 6.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х600х2000 (ГхШхВ) мм:1872374
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20610; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 81.18; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 945
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.26 m3; Площадь: 6.84 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х600х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х600х2200 (ГхШхВ) мм:1872420
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х600х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22610; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х600х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х600х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 76.87; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 958
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х600х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х600х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х600х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х600х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.38 m3; Площадь: 7.4 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х800х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х800х1800 (ГхШхВ) мм:1872467
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х800х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18810; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х800х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х800х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 92.64; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 971
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х800х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х800х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х800х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х800х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.52 m3; Площадь: 7.9 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х800х2000 (ГхШхВ) мм:1872517
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20810; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 98.92; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 984
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.68 m3; Площадь: 8.58 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1000х800х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1000х800х2200 (ГхШхВ) мм:1872564
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1000х800х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22810; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1000х800х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1000х800х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 98.11; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 997
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1000х800х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1000х800х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1000х800х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1000х800х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.84 m3; Площадь: 9.26 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х1000х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1000х1800 (ГхШхВ) мм:1873353
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE181012; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1000х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
