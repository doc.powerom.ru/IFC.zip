Properties of the parts of a building model (IFC4), part 2 of 4

# IfcElectricDistributionBoard: 1200х1000х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1000х1800 (ГхШхВ) мм:1873353
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 124.1; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1218
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1000х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1000х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1000х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1000х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.28 m3; Площадь: 10.18 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х1000х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1000х2000 (ГхШхВ) мм:1873403
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE201012; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1000х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 118.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1231
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1000х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1000х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1000х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1000х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.52 m3; Площадь: 11.02 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х1000х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1000х2200 (ГхШхВ) мм:1873453
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE221012; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1000х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1000х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 122.07; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1244
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1000х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1000х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1000х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1000х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.76 m3; Площадь: 11.86 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х1200х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1200х1800 (ГхШхВ) мм:1873504
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE181212; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1200х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 130.1; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1257
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1200х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1200х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1200х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1200х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.736 m3; Площадь: 12 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х1200х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1200х2000 (ГхШхВ) мм:1873553
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE201212; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1200х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 135.88; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
Стадии - Стадия возведения: Стадия 1
Размеры - DKC_Высота цоколя: 100 mm; Объем: 3.024 m3; Площадь: 12.96 m2
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1200х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1200х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1200х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1200х2000 (ГхШхВ) мм
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Идентификация - Марка: 1270
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Данные - DKC_Код комплектации: 100111111111
Графика - DKC_Зона обслуживания: no
Pset_ManufacturerTypeInformation - Manufacturer: DKC

# IfcElectricDistributionBoard: 1200х1200х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х1200х2200 (ГхШхВ) мм:1873600
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE221212; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х1200х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х1200х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 1200 mm; DKC_Глубина сервисной зоны: 1200 mm
Type - Текст - ADSK_Масса: 151.07; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
Стадии - Стадия возведения: Стадия 1
Размеры - DKC_Высота цоколя: 100 mm; Объем: 3.312 m3; Площадь: 13.92 m2
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х1200х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х1200х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х1200х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х1200х2200 (ГхШхВ) мм
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Идентификация - Марка: 1283
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Данные - DKC_Код комплектации: 100111111111
Графика - DKC_Зона обслуживания: no
Pset_ManufacturerTypeInformation - Manufacturer: DKC

# IfcElectricDistributionBoard: 1200х400х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х400х1800 (ГхШхВ) мм:1872930
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х400х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18412; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х400х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х400х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 64.78; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1101
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х400х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х400х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х400х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х400х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.912 m3; Площадь: 5.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х400х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х400х2000 (ГхШхВ) мм:1872980
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х400х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20412; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х400х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х400х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 69.56; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1114
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х400х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х400х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х400х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х400х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.008 m3; Площадь: 5.68 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х400х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х400х2200 (ГхШхВ) мм:1873029
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х400х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22412; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х400х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х400х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 73.75; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1127
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х400х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х400х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х400х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х400х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.104 m3; Площадь: 6.16 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х600х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х600х1800 (ГхШхВ) мм:1873079
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х600х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18612; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х600х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х600х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 76.5; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1140
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х600х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х600х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х600х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х600х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.368 m3; Площадь: 6.78 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х600х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х600х2000 (ГхШхВ) мм:1873114
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х600х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20612; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х600х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х600х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 85.98; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1153
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х600х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х600х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х600х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х600х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.512 m3; Площадь: 7.38 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х600х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х600х2200 (ГхШхВ) мм:1873160
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х600х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22612; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х600х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х600х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 81.67; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1166
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х600х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х600х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х600х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х600х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.656 m3; Площадь: 7.98 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х800х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х800х1800 (ГхШхВ) мм:1873206
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х800х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18812; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х800х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х800х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 98.101; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1179
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х800х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х800х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х800х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х800х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 1.824 m3; Площадь: 8.44 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х800х2000 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х800х2000 (ГхШхВ) мм:1873257
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х800х2000мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE20812; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х800х2000мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х800х2000 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2000 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 104.381; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1192
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х800х2000 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х800х2000 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х800х2000 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х800х2000 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.016 m3; Площадь: 9.16 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 1200х800х2200 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:1200х800х2200 (ГхШхВ) мм:1873306
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 1200х800х2200мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE22812; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 1200х800х2200мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 1200х800х2200 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 2200 mm; ADSK_Размер_Глубина: 1200 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 103.571; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1205
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 1200х800х2200 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 1200х800х2200 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 1200х800х2200 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 1200х800х2200 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 2.208 m3; Площадь: 9.88 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х1000х1800 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х1000х1800 (ГхШхВ) мм:1870853
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х1000х1800мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE18104; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х1000х1800мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_ШкафНапольный_DKC.png; ADSK_URL документации изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/163/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 400х1000х1800 (ГхШхВ) мм; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф CQE с дверью и задней панелью
Type - Материалы и отделка - DKC_Материал_Боковые панели: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Дно: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крышка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Лого: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болты: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Стойки: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Цоколь_угловой элемент: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь_фланцы: BIMLIB_СерыйRAL7011_DKC
Type - Общие - DKC_Цоколь100: 100 мм; DKC_Цоколь200: 200 мм
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_ШкафНапольный_DKC
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 1000 mm
Type - Текст - ADSK_Масса: 98; DKC_IK: 10; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 1000 кг; DKC_Цвет (дно/крышка): RAL 7011; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 100111111111
Зависимости - DKC_Боковые панели: yes; DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Рым-болт: no; DKC_Цоколь: 100 мм; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 486
Набор - DKC_Внешняя точка заземления: yes; DKC_Карман для документов: yes; DKC_Концевой выключатель: yes; DKC_Ограничитель угла открывания двери до 90°: yes; DKC_Петли на 180°: yes; DKC_Сплошное дно: yes; DKC_Улучшенная ручка: yes; DKC_Уплотнитель для кабельного ввода: yes
Прочее - Код типа: НВО_ШкафНапольный_DKC: 400х1000х1800 (ГхШхВ) мм; Семейство: НВО_ШкафНапольный_DKC: 400х1000х1800 (ГхШхВ) мм; Семейство и типоразмер: НВО_ШкафНапольный_DKC: 400х1000х1800 (ГхШхВ) мм; Тип: НВО_ШкафНапольный_DKC: 400х1000х1800 (ГхШхВ) мм
Размеры - DKC_Высота цоколя: 100 mm; Объем: 0.76 m3; Площадь: 7.86 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 400х600х1400 (ГхШхВ) мм, НВО_ШкафНапольный_DKC:400х600х1400 (ГхШхВ) мм:1747545
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7011_DKC, BIMLIB_СерыйRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф CQE с дверью и задней панелью 400х600х1400мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5CQE1464; ADSK_Наименование: Сборный шкаф CQE с дверью и задней панелью 400х600х1400мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
