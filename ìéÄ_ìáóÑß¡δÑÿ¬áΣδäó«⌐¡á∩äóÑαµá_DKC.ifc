Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-26T23:52:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 26 23:52:51 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{9A06CB05-C793-44C1-A11E-6C3C63E35721}\ifc * Database version: 5507 * Database creation date: Wed Feb 26 23:52:51 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 26 23:52:51 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 26 23:52:51 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 200х1000х800 мм (ГхШхВ), НВО_НавесныеШкафыДвойнаяДверца_DKC:200х1000х800 мм (ГхШхВ):1818456
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST с двойной дверцей 200х1000х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0812; ADSK_Наименование: Сборный шкаф ST с двойной дверцей 200х1000х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/109/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыДвойнаяДверца_DKC.png; Имя типа: 200х1000х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST с двумя дверями
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыДвойнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 39.6; DKC_IK: 10; DKC_IP: IP55; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 13
Зависимости - DKC_Видимость двери: yes; DKC_Смещение от уровня: 800 mm; DKC_Тип крепления: Нет; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 367
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыДвойнаяДверца_DKC: 200х1000х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыДвойнаяДверца_DKC: 200х1000х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыДвойнаяДверца_DKC: 200х1000х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыДвойнаяДверца_DKC: 200х1000х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.16 m3; Площадь: 2.86 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х1000х800 мм (ГхШхВ), НВО_НавесныеШкафыДвойнаяДверца_DKC:300х1000х800 мм (ГхШхВ):2033787
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST с двойной дверцей 300х800х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0813; ADSK_Наименование: Сборный шкаф ST с двойной дверцей 300х800х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыДвойнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/109/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х1000х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST с двумя дверями
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыДвойнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 1000 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 43.2; DKC_IK: 10; DKC_IP: IP55; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 13
Зависимости - DKC_Видимость двери: yes; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1795
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х1000х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х1000х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х1000х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х1000х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.24 m3; Площадь: 3.04 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х800х600 мм (ГхШхВ), НВО_НавесныеШкафыДвойнаяДверца_DKC:300х800х600 мм (ГхШхВ):2033752
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST с двойной дверцей 300х800х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0683; ADSK_Наименование: Сборный шкаф ST с двойной дверцей 300х800х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыДвойнаяДверца_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/109/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х800х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST с двумя дверями
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыДвойнаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 28.55; DKC_IK: 10; DKC_IP: IP55; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 13
Зависимости - DKC_Видимость двери: yes; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; DKC_Смещение от уровня: 800 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1793
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х800х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х800х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х800х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыДвойнаяДверца_DKC: 300х800х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 800 mm; Объем: 0.144 m3; Площадь: 1.94 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
