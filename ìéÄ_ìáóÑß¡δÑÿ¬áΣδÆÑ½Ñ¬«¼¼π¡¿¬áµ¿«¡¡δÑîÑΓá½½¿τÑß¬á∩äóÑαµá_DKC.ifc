Properties of the parts of a building model (IFC4), part 2 of 2

# IfcElectricDistributionBoard: IP54 RAL7035 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 400х600х1000 мм (ГхШхВ):2034905
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 400х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 400х600х500 мм (ГхШхВ):2034899
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP0940MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; DKC_Перфорация: no; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 400х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 20.83; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1858
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.12 m3; Площадь: 1.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 400х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 400х600х600 мм (ГхШхВ):2034901
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1240MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 400х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 22.76; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1860
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.144 m3; Площадь: 1.92 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 400х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 400х600х800 мм (ГхШхВ):2034903
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1640MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 400х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 400х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 27.68; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1862
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 400х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.192 m3; Площадь: 2.36 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 650х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 650х600х1000 мм (ГхШхВ):2034913
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP2065MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 650х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 54.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1872
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.39 m3; Площадь: 3.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 650х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 650х600х500 мм (ГхШхВ):2034907
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP0965MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 650х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 42; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1866
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.195 m3; Площадь: 1.975 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 650х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 650х600х600 мм (ГхШхВ):2034909
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1265MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 650х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 42.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1868
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.234 m3; Площадь: 2.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL7035 650х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL7035 650х600х800 мм (ГхШхВ):2034911
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1665MT; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL7035 650х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL7035 650х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 38.8; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 7035
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1870
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL7035 650х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.312 m3; Площадь: 2.71 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 400х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 400х600х1000 мм (ГхШхВ):2034921
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP2040MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 400х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 32.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1880
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.24 m3; Площадь: 2.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 400х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 400х600х500 мм (ГхШхВ):2034915
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP0940MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 400х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 21.13; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1874
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.12 m3; Площадь: 1.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 400х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 400х600х600 мм (ГхШхВ):2034917
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1240MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 400х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 23.56; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1876
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.144 m3; Площадь: 1.92 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 400х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 400х600х800 мм (ГхШхВ):2034919
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1640MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 400х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 400х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 400 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 27.56; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1878
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 400х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.192 m3; Площадь: 2.36 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 650х600х1000 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 650х600х1000 мм (ГхШхВ):2034929
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х1000 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP2065MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х1000 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 650х600х1000 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 54.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1888
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х1000 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х1000 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х1000 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х1000 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.39 m3; Площадь: 3.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 650х600х500 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 650х600х500 мм (ГхШхВ):2034923
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х500 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP0965MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х500 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 650х600х500 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 27.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1882
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х500 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х500 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х500 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х500 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.195 m3; Площадь: 1.975 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 650х600х600 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 650х600х600 мм (ГхШхВ):2034925
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х600 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1265MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х600 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 650х600х600 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 41.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1884
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х600 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х600 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х600 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х600 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.234 m3; Площадь: 2.22 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: IP54 RAL9005 650х600х800 мм (ГхШхВ), НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC:IP54 RAL9005 650х600х800 мм (ГхШхВ):2034927
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_ЧерныйRAL9005_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - DKC_Перфорация: no; ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х800 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5STIP1665MTB; ADSK_Наименование: Навесной телекоммуникационный шкаф с металлической дверцей IP54 RAL9005 650х600х800 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC002500
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC.png; ADSK_URL документации изделия: https://telecom.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/869/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: IP54 RAL9005 650х600х800 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной телекоммуникационный шкаф со стеклянной дверцей
Type - Материалы и отделка - DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Корпус: BIMLIB_ЧерныйRAL9005_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 48.5; DKC_IK: 10; DKC_IP: IP54; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 9005
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 1
Зависимости - DKC_Видимость двери: yes; DKC_Настенное крепление: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1886
Набор - DKC_Держатель концевого выключателя: yes
Прочее - Код типа: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х800 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х800 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х800 мм (ГхШхВ); Тип: НВО_НавесныеШкафыТелекоммуникационныеМеталлическаяДверца_DKC: IP54 RAL9005 650х600х800 мм (ГхШхВ)
Размеры - DKC_Смещение низа: 1000 mm; Объем: 0.312 m3; Площадь: 2.71 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
