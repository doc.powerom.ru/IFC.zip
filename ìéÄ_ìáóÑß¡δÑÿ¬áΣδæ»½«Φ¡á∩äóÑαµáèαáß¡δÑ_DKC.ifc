Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-26T23:38:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 26 23:38:21 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{F8E98B43-FFEE-4625-A00C-E17B3541A3FA}\ifc * Database version: 5507 * Database creation date: Wed Feb 26 23:38:17 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 26 23:38:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 26 23:38:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 150х250х300 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х250х300 мм (ГхШхВ) RAL3000:1968183
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х250х300 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0391-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х250х300 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; Имя типа: 150х250х300 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 250 mm; DKC_Глубина сервисной зоны: 250 mm
Type - Текст - ADSK_Масса: 4.95; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Смещение от уровня: 200 mm; DKC_Тип крепления: Нет; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 1428
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х250х300 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х250х300 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х250х300 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х250х300 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.01125 m3; Площадь: 0.37 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 150х300х200 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х300х200 мм (ГхШхВ) RAL3000:1987488
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х300х200 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0231-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х300х200 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 150х300х200 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 200 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 3.98; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1564
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х200 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х200 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х200 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х200 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.009 m3; Площадь: 0.345 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 150х300х300 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х300х300 мм (ГхШхВ) RAL3000:1987544
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х300х300 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0331-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х300х300 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 150х300х300 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 5.4; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1567
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х300 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х300 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х300 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х300 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.0135 m3; Площадь: 0.45 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 150х300х400 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х300х400 мм (ГхШхВ) RAL3000:1987599
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х300х400 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0431-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х300х400 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 150х300х400 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 6.75; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1570
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х400 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х400 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х400 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х400 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.018 m3; Площадь: 0.555 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 150х300х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х300х500 мм (ГхШхВ) RAL3000:1987656
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х300х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0531-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х300х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 150х300х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 8.24; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1573
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х300х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.0225 m3; Площадь: 0.66 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 150х400х300 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:150х400х300 мм (ГхШхВ) RAL3000:1987714
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 150х400х300 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0341-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 150х400х300 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 150х400х300 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 7.08; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1576
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х400х300 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х400х300 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х400х300 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 150х400х300 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.018 m3; Площадь: 0.625 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х300х400 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х300х400 мм (ГхШхВ) RAL3000:1987771
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х300х400 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0432-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х300х400 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х300х400 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 7.43; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1579
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х400 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х400 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х400 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х400 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.024 m3; Площадь: 0.59 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х300х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х300х500 мм (ГхШхВ) RAL3000:1987842
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х300х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0532-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х300х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х300х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 300 mm; DKC_Глубина сервисной зоны: 300 mm
Type - Текст - ADSK_Масса: 8.87; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1597
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х300х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.03 m3; Площадь: 0.7 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х300 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х400х300 мм (ГхШхВ) RAL3000:1987896
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х400х300 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0342-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х400х300 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х300 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 300 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 7.69; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1600
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х300 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х300 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х300 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х300 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.024 m3; Площадь: 0.66 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х400 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х400х400 мм (ГхШхВ) RAL3000:1987956
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х400х400 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0442-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х400х400 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х400 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 9.47; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1603
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х400 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х400 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х400 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х400 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.032 m3; Площадь: 0.8 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х400х500 мм (ГхШхВ) RAL3000:1988014
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х400х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0542-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х400х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 12.1; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1606
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.04 m3; Площадь: 0.94 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х400х600 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х400х600 мм (ГхШхВ) RAL3000:1988070
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х400х600 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0642-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х400х600 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х400х600 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 13.78; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1609
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х600 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х600 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х600 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х400х600 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.048 m3; Площадь: 1.08 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х500х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х500х500 мм (ГхШхВ) RAL3000:1988144
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х500х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0552-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х500х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х500х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 13.72; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1612
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.05 m3; Площадь: 1.2 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х500х600 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х500х600 мм (ГхШхВ) RAL3000:1988198
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х500х600 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0652-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х500х600 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х500х600 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 16.77; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1615
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х600 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х600 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х600 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х600 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.06 m3; Площадь: 1.37 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х500х700 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х500х700 мм (ГхШхВ) RAL3000:1988258
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х500х700 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0752-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х500х700 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х500х700 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 700 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 18.3; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1618
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
