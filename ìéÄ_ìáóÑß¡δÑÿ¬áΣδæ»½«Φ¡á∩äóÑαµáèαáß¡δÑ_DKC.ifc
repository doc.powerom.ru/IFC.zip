Properties of the parts of a building model (IFC4), part 2 of 3

# IfcElectricDistributionBoard: 200х500х700 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х500х700 мм (ГхШхВ) RAL3000:1988258
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х700 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х700 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х700 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х500х700 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.07 m3; Площадь: 1.54 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х600х1200 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х600х1200 мм (ГхШхВ) RAL3000:1988495
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х600х1200 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST1262-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х600х1200 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х600х1200 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 33.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1630
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х1200 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х1200 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х1200 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х1200 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.144 m3; Площадь: 2.88 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х600х400 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х600х400 мм (ГхШхВ) RAL3000:1988319
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х600х400 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0462-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х600х400 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х600х400 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 14; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1621
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х400 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х400 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х400 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х400 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.048 m3; Площадь: 1.28 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х600х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х600х500 мм (ГхШхВ) RAL3000:1988377
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х600х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0562-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х600х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х600х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 15; DKC_IK: 10; DKC_IP: IP66; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1624
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.06 m3; Площадь: 1.48 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х600х800 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х600х800 мм (ГхШхВ) RAL3000:1988432
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х600х800 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0862-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х600х800 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х600х800 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 24.83; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1627
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х800 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х800 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х800 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х600х800 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.096 m3; Площадь: 2.08 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 200х800х800 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:200х800х800 мм (ГхШхВ) RAL3000:1988564
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 200х800х800 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0882-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 200х800х800 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 200х800х800 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 800 mm; DKC_Глубина сервисной зоны: 800 mm
Type - Текст - ADSK_Масса: 32.25; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1633
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х800х800 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х800х800 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х800х800 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 200х800х800 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.128 m3; Площадь: 2.88 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х400х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х400х500 мм (ГхШхВ) RAL3000:1988624
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х400х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0549-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х400х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х400х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 12.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1636
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.05 m3; Площадь: 0.985 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х400х600 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х400х600 мм (ГхШхВ) RAL3000:1988681
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х400х600 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0649-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х400х600 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х400х600 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 400 mm; DKC_Глубина сервисной зоны: 400 mm
Type - Текст - ADSK_Масса: 15.07; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1639
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х600 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х600 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х600 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х400х600 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.06 m3; Площадь: 1.13 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х500х700 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х500х700 мм (ГхШхВ) RAL3000:1988745
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х500х700 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0759-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х500х700 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х500х700 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 700 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 20.17; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1642
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х500х700 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х500х700 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х500х700 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х500х700 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.0875 m3; Площадь: 1.6 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х1000 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х600х1000 мм (ГхШхВ) RAL3000:1988923
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х600х1000 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST1069-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х600х1000 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х1000 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 32.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1651
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х1000 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х1000 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х1000 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х1000 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.15 m3; Площадь: 2.56 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х600 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х600х600 мм (ГхШхВ) RAL3000:1988803
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х600х600 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0669-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х600х600 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х600 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 600 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 21.45; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1645
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х600 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х600 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х600 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х600 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.09 m3; Площадь: 1.74 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 250х600х800 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:250х600х800 мм (ГхШхВ) RAL3000:1988862
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 250х600х800 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0869-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 250х600х800 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 250х600х800 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 800 mm; ADSK_Размер_Глубина: 250 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 27.7; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1648
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х800 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х800 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х800 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 250х600х800 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.12 m3; Площадь: 2.15 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х500х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:300х500х500 мм (ГхШхВ) RAL3000:1988999
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 300х500х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0553-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 300х500х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х500х500 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 500 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 500 mm; DKC_Глубина сервисной зоны: 500 mm
Type - Текст - ADSK_Масса: 15.9; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1657
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х500х500 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х500х500 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х500х500 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х500х500 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.075 m3; Площадь: 1.3 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х1000 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:300х600х1000 мм (ГхШхВ) RAL3000:1989180
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 300х600х1000 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST1063-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 300х600х1000 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х1000 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 1000 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 34.85; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1666
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1000 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1000 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1000 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1000 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.18 m3; Площадь: 2.64 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х1200 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:300х600х1200 мм (ГхШхВ) RAL3000:1989249
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 300х600х1200 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST1263-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 300х600х1200 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х1200 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 1200 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 39; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1669
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1200 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1200 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1200 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1200 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.216 m3; Площадь: 3.06 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х1400 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:300х600х1400 мм (ГхШхВ) RAL3000:1989316
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 300х600х1400 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST1463-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 300х600х1400 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC.png; ADSK_URL документации изделия: https://st.dkc.ru/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/868/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 300х600х1400 мм (ГхШхВ) RAL3000; Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Сборный шкаф ST со сплошной дверцей RAL3000
Type - Материалы и отделка - DKC_Материал_Защитный козырек: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_КрасныйRAL3000_DKC; DKC_Материал_Крепление к столбу: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Напольное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Панель для модульного оборудования: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Рым-болт: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Цоколь: BIMLIB_СерыйRAL7011_DKC
Type - Прочее - Категория: Электрооборудование; DKC_Крепление_Напольное: Напольное крепление; DKC_Крепление_Настенное: Настенное крепление; DKC_Крепление_Нет: Нет; DKC_Крепление_Цоколь: Цоколь ST; Имя семейства: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC
Type - Размеры - ADSK_Размер_Высота: 1400 mm; ADSK_Размер_Глубина: 300 mm; ADSK_Размер_Ширина: 600 mm; DKC_Глубина сервисной зоны: 600 mm
Type - Текст - ADSK_Масса: 41.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1; DKC_Максимальный ток: 6300 A; DKC_Несущая способность: 60 кг; DKC_Толщина двери: Сталь 1,5 мм; DKC_Толщина каркаса: Сталь 1,2 мм; DKC_Цвет (корпус): RAL 3000
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 411000
Зависимости - DKC_Видимость двери: yes; DKC_Защитный козырек: no; DKC_Панель для модульного оборудования: no; DKC_Рым-болт: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 200 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1672
Набор - DKC_Держатель концевого выключателя: yes; DKC_Ограничитель угла открывания двери до 90°: yes
Прочее - Код типа: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1400 мм (ГхШхВ) RAL3000; Семейство: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1400 мм (ГхШхВ) RAL3000; Семейство и типоразмер: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1400 мм (ГхШхВ) RAL3000; Тип: НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC: 300х600х1400 мм (ГхШхВ) RAL3000
Размеры - DKC_Смещение низа: 200 mm; Объем: 0.252 m3; Площадь: 3.48 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 300х600х500 мм (ГхШхВ) RAL3000, НВО_НавесныеШкафыСплошнаяДверцаКрасные_DKC:300х600х500 мм (ГхШхВ) RAL3000:1989060
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_КрасныйRAL3000_DKC, BIMLIB_СерыйRAL7011_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Сборный шкаф ST со сплошной дверцей 300х600х500 мм (ГхШхВ) RAL3000; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: R5ST0563-RAL3000; ADSK_Наименование: Сборный шкаф ST со сплошной дверцей 300х600х500 мм (ГхШхВ) RAL3000; ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
