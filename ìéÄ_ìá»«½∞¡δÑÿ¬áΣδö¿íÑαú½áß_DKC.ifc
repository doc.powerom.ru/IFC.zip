Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-26T23:57:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 26 23:57:08 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{100FEDC5-FFDF-4FDC-BA19-F756717617A3}\ifc * Database version: 5507 * Database creation date: Wed Feb 26 23:57:06 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Feb 26 23:57:07 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 26 23:57:07 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 330х580х1390 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х580х1390 мм (ГхШхВ):2033886
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х580х1390 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077508109; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х580х1390 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х580х1390 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 1390 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 28.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1800
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х580х1390 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х580х1390 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х580х1390 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х580х1390 мм (ГхШхВ)
Размеры - Объем: 0.266046 m3; Площадь: 3.4051 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х580х400 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х580х400 мм (ГхШхВ):1818571
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х580х400 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077500106; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х580х400 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; Имя типа: 330х580х400 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 14.5; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 370
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х580х400 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х580х400 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х580х400 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х580х400 мм (ГхШхВ)
Размеры - Объем: 0.07656 m3; Площадь: 1.3558 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х580х580 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х580х580 мм (ГхШхВ):2033854
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х580х580 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077503100; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х580х580 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х580х580 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 580 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 16.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1798
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х580х580 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х580х580 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х580х580 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х580х580 мм (ГхШхВ)
Размеры - Объем: 0.111012 m3; Площадь: 1.7284 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х580х940 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х580х940 мм (ГхШхВ):2033870
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х580х940 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077505105; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х580х940 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х580х940 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 940 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 23; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1799
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х580х940 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х580х940 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х580х940 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х580х940 мм (ГхШхВ)
Размеры - Объем: 0.179916 m3; Площадь: 2.4736 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х490 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х685х490 мм (ГхШхВ):2033905
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х685х490 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077702108; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х685х490 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х490 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 490 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 16.54; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1801
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х685х490 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х685х490 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х685х490 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х685х490 мм (ГхШхВ)
Размеры - Объем: 0.110764 m3; Площадь: 1.86392 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х715 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:330х685х715 мм (ГхШхВ):2033919
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х685х715 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077704104; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х685х715 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х715 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 715 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 17.8; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 1802
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х685х715 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х685х715 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х685х715 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х685х715 мм (ГхШхВ)
Размеры - Объем: 0.161626 m3; Площадь: 2.40055 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х940 мм (ГхШхВ) (2)
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 330х685х940 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077705101; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 330х685х940 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х940 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 940 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 25.1; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 330х685х940 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 330х685х940 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 330х685х940 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 330х685х940 мм (ГхШхВ)
Размеры - Объем: 0.212487 m3; Площадь: 2.93717 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
Name (НВО_НапольныеШкафыФиберглас_DKC:330х685х940 мм (ГхШхВ):...) | Марка
2033937 | 1803
2033953 | 1804

# IfcElectricDistributionBoard: 460х580х1390 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х580х1390 мм (ГхШхВ):2033999
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х580х1390 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077518108; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х580х1390 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х580х1390 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 1390 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 38.38; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1807
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х580х1390 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х580х1390 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х580х1390 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х580х1390 мм (ГхШхВ)
Размеры - Объем: 0.370852 m3; Площадь: 3.6612 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х580х580 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х580х580 мм (ГхШхВ):2033966
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х580х580 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077513109; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х580х580 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х580х580 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 580 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 17; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1805
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х580х580 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х580х580 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х580х580 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х580х580 мм (ГхШхВ)
Размеры - Объем: 0.154744 m3; Площадь: 1.8792 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х580х940 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х580х940 мм (ГхШхВ):2033982
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х580х940 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077515104; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х580х940 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х580х940 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 940 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 27.6; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1806
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х580х940 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х580х940 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х580х940 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х580х940 мм (ГхШхВ)
Размеры - Объем: 0.250792 m3; Площадь: 2.6712 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х1390 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х685х1390 мм (ГхШхВ):2034064
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х685х1390 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077718104; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х685х1390 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х1390 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 1390 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 40.16; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1811
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х685х1390 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х685х1390 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х685х1390 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х685х1390 мм (ГхШхВ)
Размеры - Объем: 0.437989 m3; Площадь: 4.28017 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х490 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х685х490 мм (ГхШхВ):2034013
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х685х490 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077712107; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х685х490 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х490 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 490 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 17; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1808
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х685х490 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х685х490 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х685х490 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х685х490 мм (ГхШхВ)
Размеры - Объем: 0.154399 m3; Площадь: 2.01667 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х715 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х685х715 мм (ГхШхВ):2034028
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х685х715 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077714103; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х685х715 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х715 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 715 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 23.76; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1809
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х685х715 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х685х715 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х685х715 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х685х715 мм (ГхШхВ)
Размеры - Объем: 0.225296 m3; Площадь: 2.58255 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х940 мм (ГхШхВ), НВО_НапольныеШкафыФиберглас_DKC:460х685х940 мм (ГхШхВ):2034047
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Напольный шкаф Conchiglia из фибергласа 460х685х940 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077715100; ADSK_Наименование: Напольный шкаф Conchiglia из фибергласа 460х685х940 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НапольныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х940 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Напольный шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Рама для крепления к полу: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НапольныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 940 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 29.42; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 0
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Монтажная плата вторая: no; DKC_Рама для крепления к полу: no; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 1810
Прочее - Код типа: НВО_НапольныеШкафыФиберглас_DKC: 460х685х940 мм (ГхШхВ); Семейство: НВО_НапольныеШкафыФиберглас_DKC: 460х685х940 мм (ГхШхВ); Семейство и типоразмер: НВО_НапольныеШкафыФиберглас_DKC: 460х685х940 мм (ГхШхВ); Тип: НВО_НапольныеШкафыФиберглас_DKC: 460х685х940 мм (ГхШхВ)
Размеры - Объем: 0.296194 m3; Площадь: 3.14842 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
