Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
Time: 2020-02-27T00:01:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 27 00:01:29 2020 * Host: SERGEY_MIKHALEV * Database: C:\Users\mkhlv\AppData\Local\Temp\{541BA1C6-9B50-4FCE-A8D6-3600812E91B6}\ifc * Database version: 5507 * Database creation date: Thu Feb 27 00:01:28 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Feb 27 00:01:28 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 27 00:01:29 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - Reference: Сведения о проекте; NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcElectricDistributionBoard: 330х580х370 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х580х370 мм (ГхШхВ):1826672
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х580х370 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077501907; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х580х370 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; Имя типа: 330х580х370 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет
Type - Размеры - ADSK_Размер_Высота: 370 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 13.08; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Смещение от уровня: 1000 mm; DKC_Тип крепления: Нет; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 376
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х580х370 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х580х370 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х580х370 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х580х370 мм (ГхШхВ)
Размеры - Объем: 0.070818 m3; Площадь: 1.2937 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Усредненный коэффициент спроса: 1; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х580х550 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х580х550 мм (ГхШхВ):2034136
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х580х550 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077503902; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х580х550 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х580х550 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 550 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 16.44; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 1812
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х580х550 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х580х550 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х580х550 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х580х550 мм (ГхШхВ)
Размеры - Объем: 0.10527 m3; Площадь: 1.6663 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х580х910 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х580х910 мм (ГхШхВ):2034165
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х580х910 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077505907; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х580х910 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х580х910 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 910 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 23.5; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1813
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х580х910 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х580х910 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х580х910 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х580х910 мм (ГхШхВ)
Размеры - Объем: 0.174174 m3; Площадь: 2.4115 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х460 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х685х460 мм (ГхШхВ):2034187
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х685х460 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077702900; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х685х460 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х460 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 460 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 16.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1814
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х685х460 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х685х460 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х685х460 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х685х460 мм (ГхШхВ)
Размеры - Объем: 0.103983 m3; Площадь: 1.79237 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х685 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х685х685 мм (ГхШхВ):2034212
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х685х685 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077704906; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х685х685 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х685 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 685 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 21.04; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1815
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х685х685 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х685х685 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х685х685 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х685х685 мм (ГхШхВ)
Размеры - Объем: 0.154844 m3; Площадь: 2.329 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 330х685х910 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:330х685х910 мм (ГхШхВ):2034230
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 330х685х910 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077705903; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 330х685х910 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 330х685х910 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 910 mm; ADSK_Размер_Глубина: 330 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 25.4; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1816
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 330х685х910 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 330х685х910 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 330х685х910 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 330х685х910 мм (ГхШхВ)
Размеры - Объем: 0.205705 m3; Площадь: 2.86562 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х580х550 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:460х580х550 мм (ГхШхВ):2034259
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 460х580х550 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077513901; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 460х580х550 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х580х550 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 550 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 17.54; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1817
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 460х580х550 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 460х580х550 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 460х580х550 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 460х580х550 мм (ГхШхВ)
Размеры - Объем: 0.14674 m3; Площадь: 1.8132 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х580х910 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:460х580х910 мм (ГхШхВ):2034286
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 460х580х910 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077515906; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 460х580х910 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х580х910 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 910 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 580 mm; DKC_Глубина сервисной зоны: 580 mm
Type - Текст - ADSK_Масса: 26.76; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Марка: 1818
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 460х580х910 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 460х580х910 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 460х580х910 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 460х580х910 мм (ГхШхВ)
Размеры - Объем: 0.242788 m3; Площадь: 2.6052 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х460 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:460х685х460 мм (ГхШхВ):2034315
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 460х685х460 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077712909; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 460х685х460 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х460 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 460 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 19.2; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1819
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 460х685х460 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 460х685х460 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 460х685х460 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 460х685х460 мм (ГхШхВ)
Размеры - Объем: 0.144946 m3; Площадь: 1.94122 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х685 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:460х685х685 мм (ГхШхВ):2034341
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 460х685х685 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077714905; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 460х685х685 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х685 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 685 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 23.74; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1820
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 460х685х685 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 460х685х685 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 460х685х685 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 460х685х685 мм (ГхШхВ)
Размеры - Объем: 0.215843 m3; Площадь: 2.5071 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W

# IfcElectricDistributionBoard: 460х685х910 мм (ГхШхВ), НВО_НавесныеШкафыФиберглас_DKC:460х685х910 мм (ГхШхВ):2034369
In: Этаж 01
Type - PredefinedType: DISTRIBUTIONBOARD; Classification: 23.80.30.11.17 (Uniformat); Material: BIMLIB_СерыйRAL7035_DKC, BIMLIB_СерыйФиберRAL7035_DKC
Type - Данные - ADSK_Версия семейства: 1.0; ADSK_Группирование: Навесной шкаф Conchiglia из фибергласа 460х685х910 мм (ГхШхВ); ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 077715902; ADSK_Наименование: Навесной шкаф Conchiglia из фибергласа 460х685х910 мм (ГхШхВ); ADSK_Обозначение: ГОСТ Р 32127; ETIM Article Class: EC000261
Type - Идентификация - Изображение типоразмера: Растровое изображение: НВО_НавесныеШкафыФиберглас_DKC.jpg; ADSK_URL документации изделия: https://conchiglia.dkc.ru; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/779/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/ru/; Заголовок OmniClass: Distribution Boards and Control Panels; Изготовитель: DKC; Имя типа: 460х685х910 мм (ГхШхВ); Код по классификатору: 23.80.30.11.17; Комментарии к типоразмеру: 1. Шкаф; Номер OmniClass: 23.80.30.11.17; Описание: Навесной шкаф Conchiglia из фибергласа
Type - Материалы и отделка - DKC_Материал_Дверь: BIMLIB_СерыйФиберRAL7035_DKC; DKC_Материал_Корпус: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Крепление к столбу: BIMLIB_ЧерныйRAL9005_DKC; DKC_Материал_Монтажная плата: BIMLIB_СерыйRAL7035_DKC; DKC_Материал_Настенное крепление: BIMLIB_СерыйRAL7011_DKC; DKC_Материал_Ручка: BIMLIB_СерыйRAL7035_DKC
Type - Прочее - Категория: Электрооборудование; Крепление_Настенное: Настенное крепление; Крепление_Нет: Нет; Имя семейства: НВО_НавесныеШкафыФиберглас_DKC
Type - Размеры - ADSK_Размер_Высота: 910 mm; ADSK_Размер_Глубина: 460 mm; ADSK_Размер_Ширина: 685 mm; DKC_Глубина сервисной зоны: 685 mm
Type - Текст - ADSK_Масса: 28.03; DKC_IK: 10; DKC_IP: IP65; DKC_Киматическое исполнение: УХЛ1
Type - Электросети - Нагрузки - ADSK_Напряжение: 1000 V
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - DKC_Зона обслуживания: no
Данные - DKC_Код комплектации: 20
Зависимости - DKC_Видимость двери: yes; DKC_Монтажная плата: no; DKC_Тип крепления: Нет; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; DKC_Смещение от уровня: 1000 mm; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 1821
Прочее - Код типа: НВО_НавесныеШкафыФиберглас_DKC: 460х685х910 мм (ГхШхВ); Семейство: НВО_НавесныеШкафыФиберглас_DKC: 460х685х910 мм (ГхШхВ); Семейство и типоразмер: НВО_НавесныеШкафыФиберглас_DKC: 460х685х910 мм (ГхШхВ); Тип: НВО_НавесныеШкафыФиберглас_DKC: 460х685х910 мм (ГхШхВ)
Размеры - Объем: 0.286741 m3; Площадь: 3.07297 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Нагрузки - Усредненный коэффициент спроса: 1; Полная установленная мощность, фаза B: 0 W; Полная установленная мощность, фаза А: 0 W; Полная установленная мощность, фаза С: 0 W; Расчетная нагрузка: 0 W; Установленная полная мощность: 0 W
